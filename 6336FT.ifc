Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-31T15:02:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 31 15:02:10 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{FE305B06-C73B-498A-80D2-84CDF26CE104}\ifc * Database version: 5507 * Database creation date: Fri Aug 31 15:02:09 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 31 15:02:09 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 31 15:02:09 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6336FT Washbasin faucet, 230/12 V, 6336FT:6336FT Washbasin faucet, 230/12 V:333750
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - FaucetNominalDepth: 161.5 mm; FaucetNominalHeight: 292.5 mm; FaucetNominalWidth: 72 mm; HandShowerNominalDepth: 64.5 mm; HandShowerNominalHeight: 286.5 mm; HandShowerNominalWidth: 46 mm; InletConnectionSize: 16 mm; Projection: 120 mm
Type - Electrical(Type) - Electrical Connection: 230 / 12 V; Electronic Parts: Autofocus sensor; Operating Voltage: 12 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 6336FT; ConvergoRefNr: 0087-1809-0139-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for washbasins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 29/08/2018
Type - Green Building Properties(Type) - EAN Number: 6414150076442; EMC Directive: 2004/108/EY; EN Standard: EN 15091; ETA-Danmark: VA 1.42/19925; LVI Number: 6110185; Noise Class: I (ISO 3822); Protection Class: IP 55 / transformer IP 40; RSK Number: 8430499; STF Certificate: STF VTT-RTH-00031-11; VVS Number: 704274534
Type - Identity Data(Type) - Class: Plug transformer, touchless; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;POL;RUS;SWE;UKR; Model: 6336FT Washbasin faucet, 230/12 V; Name_en: 6336FT Washbasin faucet, 230/12 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 6336FT; Product Datasheet: https://www.oras.com/datasheet/6336FT/en; Product Family: Oras Electra; Product URL: https://www.oras.com/en/products/oras/product/6336FT; Type Name: 6336FT Washbasin faucet, 230/12 V; Usage Group: Offices, personnel sanitary facilities;Toilets for the Disabled;Pharmacies, Opticians, Dentists;Health centers & Child welfare clinics;Hospitals;Food stores
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G3/8; Flow Rate At 300kPa With Flow Controller: 0.00353147 m3/s; Hand Shower: Bidetta hand shower; Installation and Maintenance: https://www.oras.com/fileadmin/resources/109981_PDM_943188_0_(943188-01-16).pdf; Installation Type: Deck mounted; Intelligent After Flow Period: 2 s ± 1 s; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 120; Mechanical Parts: Litter filter(s); Pressure Loss With Flow 01ls: 200000 Pa; Recognition Range: optimally preset; Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP6336FT/
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6336FT; Features: Plug transformer, touchless; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6336FT; Name: 6336FT Washbasin faucet, 230/12 V; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:70x160x295 mm / Hand shower: 50x65x290 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Text(Type) - Health Sales Arguments: Touch-free operation. Maximum comfort, maximum hygiene.
Pset_ManufacturerTypeInformation - ModelReference: 6336FT; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 6336FT Washbasin faucet, 230/12 V
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.116462 m2; Volume: 0.0042633 m3
Identity Data - Mark: 11
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 6336FT: 6336FT Washbasin faucet, 230/12 V; Family and Type: 6336FT: 6336FT Washbasin faucet, 230/12 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6336FT: 6336FT Washbasin faucet, 230/12 V; Type Id: 6336FT: 6336FT Washbasin faucet, 230/12 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
